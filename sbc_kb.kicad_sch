File: sbc_kb.kicad_sch (KiCad schematic)
At the start: 19 parts, among them J1 Mini-DIN-6, J2 Mini-DIN-6, U19 7406, U20 VT82C42 PS2 CONTROLLER

Commit message: bringing over learnings/improvements from prototype board
Parts:
- removed R27, R28, R29, R30, R31: 10k, Resistor_SMD:R_0805_2012Metric, symbol Device:R_US
Connections:
- net TH_PROG is gone; now on net +5V: U20.25 (TH_PROG)
- net TH_SS is gone; now on net +5V: U20.5 (TH_SS)
- net TH_SSPP is gone; now on net +5V: U20.26 (TH_SSPP)
- net TL_EA is gone; now on net GND: U20.7 (TL_EA)
- net XTAL1 is gone; now on net GND: U20.2 (XTAL1)

Commit message: more pcb routing, implementing learnings from the prototype board
Parts:
- added D4: 1N4001, Diode_THT:D_DO-41_SOD81_P10.16mm_Horizontal, symbol Diode:1N4001
- F1: value 1A -> Bourns MF-RHT100; footprint Fuse:Fuse_1206_3216Metric -> Fuse:Fuse_Bourns_MF-RHT100
Connections:
- net +5V: now also D4.2 (A); no longer L1.1
- net KB_CLOCK: no longer U20.1 (TEST0)
- net KB_DATA: no longer U20.27 (P10)
- net MOUSE_CLOCK: no longer U20.39 (TEST1)
- net MOUSE_DATA: no longer U20.28 (P11)
- net KB_DATA_L: now reaches L2.1, U19.2
- net KB_DATA_L: now also U20.27 (P10)
- net MOUSE_DATA_L: now reaches L5.1, U19.8
- net MOUSE_DATA_L: now also U20.28 (P11)
- net MOUSE_CLOCK_L: now reaches L4.1, U19.6
- net MOUSE_CLOCK_L: now also U20.39 (TEST1)
- net KB_CLOCK_L: now reaches L3.1, U19.4
- net KB_CLOCK_L: now also U20.1 (TEST0)
- new net: D4.1 (K), L1.1
Other:
- moved on the sheet: C11, F1, J1, L1

Commit message: pcb is fully routed, working on power capacitor tweaks, some ROM testing
Parts:
- F1: value Bourns MF-RHT100 -> 1A PTC fuse
- renumbered C11 to C2, C20 to C22, C13 to C3, C21 to C9, D4 to D1, L3 to L2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
Connections:
- net GND: now also U4.11, U4.13
- net 8MHz renamed KBC_CLK
- no-connect marks 17 -> 15
Other:
- moved on the sheet: C2, C3, D1, F1, J1, J2, L1, L2, L3, L4, L5, U4A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

Commit message: added ATtiny for SMC, added PC speaker
Parts:
- removed L1, L2, L3, L4, L5: RFC, Inductor_SMD:L_0805_2012Metric, symbol Device:L
- added FB1: FerriteBead, Inductor_THT:L_Axial_L5.3mm_D2.2mm_P10.16mm_Horizontal_Vishay_IM-1, symbol Device:FerriteBead
- added FB2, FB3, FB4, FB5: FerriteBead, Inductor_THT:L_Axial_L9.5mm_D4.0mm_P2.54mm_Vertical_Fastron_SMCC, symbol Device:FerriteBead
- added J3: PS/2 Protection Bypass, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x02
- renumbered C22 to C26, C2 to C3, C3 to C4, U8 to U9
Connections:
- net +5V: now also J3.2 (Pin_2)
- net 5V_PS2: now also J3.1 (Pin_1)
- net KB_CLOCK: now also FB2.2
- net KB_CLOCK_L: now also FB2.1
- net KB_DATA: now also FB3.2
- net KB_DATA_L: now also FB3.1
- net MOUSE_CLOCK: now also FB5.2
- net MOUSE_CLOCK_L: now also FB5.1
- net MOUSE_DATA: now also FB4.2
- net MOUSE_DATA_L: now also FB4.1
- net at F1.1: now also FB1.2
- net at D1.1 (K): now also FB1.1

Commit message: fix a few schematic bugs, missing pull-ups and pull-downs in particular
Parts:
- added R35, R36, R37, R38: 10k, Resistor_SMD:R_0805_2012Metric, symbol Device:R_US
Connections:
- net +5V: now also R35.1, R36.1, R37.1, R38.1
- net KB_CLOCK_L: now also R36.2
- net KB_DATA_L: now also R35.2
- net MOUSE_CLOCK_L: now also R37.2
- net MOUSE_DATA_L: now also R38.2
Other:
- moved on the sheet: FB2, FB3, FB4, FB5
