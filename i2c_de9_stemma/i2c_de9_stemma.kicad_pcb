# Repository miselin/M88

File README.md:

# The M88 Computer

This repository contains the KiCad project(s) and ROM source code for the M88 computer project.
Learn more about the project at [https://m88.computer](https://m88.computer).

## M88

The top-level KiCad project is the main KiCad project for the M88's Micro-ATX motherboard.

## ISA-to-I2C Bridge

The `isa_i2c` directory contains a KiCad project for an ISA-to-I2C bridge, designed around
readily available parts with only one SMT IC.

## ISA Break-out

The `isa_breakout` directory contains a KiCad project for an ISA break-out card that makes
connecting ISA bus lines to a logic analyzer much easier.

## Programs

The `programs` directory contains the main BIOS ROM for the M88, as well as utilities for
building it. The M88 BIOS ROM is _not_ fully PC-compatible and it is not recommended to use it
on other systems, at this stage.

## Licensing

The computer design and schematics are licensed under the terms of the CERN Open Hardware Licence
Version 2 - Permissive license, which can be found in `LICENSE.txt`.

The software under the `programs` directory is licensed under the MIT license, which can be found
in `programs/LICENSE.txt`.

## KiCad design isa_i2c/isa_i2c.kicad_pcb

Board: 2 copper layers, 99.7 x 78.3 mm, 19 parts (0 on the bottom side), 46 nets.

Parts:
C1, C2, C7: 0.1 uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C3: 10-100uF 16V Electrolytic; CP_Radial_D5.0mm_P2.00mm
C4: 0.1 uF; C_0603_1608Metric
J1: DE9_Receptacle; L77SDE09SA4CH4F
J8: Bus_ISA_8bit; BUS_ISA_8BIT
J10: Conn_01x04; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
R1, R2: 2.2k 1/8W; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R4, R5: 47 1/8W; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RN1, RN2: 10k; R_Array_SIP9
SW1: SW_DIP_x08; SW_DIP_SPSTx08_Slide_9.78x22.5mm_W7.62mm_P2.54mm
U1: 74AHC1G04; SOT-23-5
U2: 74HC245; DIP-20_W7.62mm
U3: PCF8584; SOIC-20W_7.5x12.8mm_P1.27mm
U7: 74HCT688; DIP-20_W7.62mm

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C7.1, J1.7, J8.3 (VCC), J8.29 (VCC), J10.3, R1.2, R2.2, RN2.1 (common), SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, SW1.7, SW1.8, U1.5 (VCC), U2.20 (VCC), U3.4 (~IACK), U3.20 (VDD), U7.20 (VCC)
/AEN: J8.42 (AEN), U7.1 (G)
/BA00: J8.62 (BA00), U3.6 (A0)
/BA02: J8.60 (BA02), U7.2 (P0)
/BA03: J8.59 (BA03), U7.4 (P1)
/BA04: J8.58 (BA04), U7.6 (P2)
/BA05: J8.57 (BA05), U7.8 (P3)
/BA06: J8.56 (BA06), U7.11 (P4)
/BA07: J8.55 (BA07), U7.13 (P5)
/BA08: J8.54 (BA08), U7.15 (P6)
/BA09: J8.53 (BA09), U7.17 (P7)
/CA2: RN1.2 (R1), SW1.16, U7.3 (R0)
/CA3: RN1.3 (R2), SW1.15, U7.5 (R1)
/CA4: RN1.4 (R3), SW1.14, U7.7 (R2)
/CA5: RN1.5 (R4), SW1.13, U7.9 (R3)
/CA6: RN1.6 (R5), SW1.12, U7.12 (R4)
/CA7: RN1.7 (R6), SW1.11, U7.14 (R5)
/CA8: RN1.8 (R7), SW1.10, U7.16 (R6)
/CA9: RN1.9 (R8), SW1.9, U7.18 (R7)
/CLK: J8.20 (CLK), U3.1 (CLK)
/D0: RN2.2 (R1), U2.18 (B0), U3.7 (D0)
/D1: RN2.3 (R2), U2.17 (B1), U3.8 (D1)
/D2: RN2.4 (R3), U2.16 (B2), U3.9 (D2)
/D3: RN2.5 (R4), U2.15 (B3), U3.11 (D3)
/D4: RN2.6 (R5), U2.14 (B4), U3.12 (D4)
/D5: RN2.7 (R6), U2.13 (B5), U3.13 (D5)
/D6: RN2.8 (R7), U2.12 (B6), U3.14 (D6)
/D7: RN2.9 (R8), U2.11 (B7), U3.15 (D7)
/DB0: J8.40 (DB0), U2.2 (A0)
/DB1: J8.39 (DB1), U2.3 (A1)
/DB2: J8.38 (DB2), U2.4 (A2)
/DB3: J8.37 (DB3), U2.5 (A3)
/DB4: J8.36 (DB4), U2.6 (A4)
/DB5: J8.35 (DB5), U2.7 (A5)
/DB6: J8.34 (DB6), U2.8 (A6)
/DB7: J8.33 (DB7), U2.9 (A7)
/PCF_SCL: R1.1, R5.1, U3.3 (SCL)
/PCF_SDA: R2.1, R4.1, U3.2 (SDA)
/RESET: J8.2 (RESET), U1.2
/SCL: J1.8, J10.1, R5.2
/SDA: J1.6, J10.2, R4.2
/~CS: U2.19 (CE), U3.17 (~CS), U7.19 (P=R)
/~IOR: J8.14 (~IOR), U2.1 (A->B), U3.16 (~RD)
/~IOW: J8.13 (~IOW), U3.18 (~WR)
/~RESET: U1.4, U3.19 (~RST)
GND: C1.2, C2.2, C3.2, C4.2, C7.2, J1.1, J1.2, J1.3, J1.4, J8.1 (GND), J8.10 (GND), J8.31 (GND), J10.4, RN1.1 (common), U1.3 (GND), U2.10 (GND), U3.10 (VSS), U7.10 (GND)

## KiCad design isa_breakout/isa_breakout.kicad_pcb

Parts:
J1: Bus_ISA_8bit; BUS_ISA_8BIT
J2: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
J3: Conn_01x20; PinHeader_1x20_P2.54mm_Vertical
J4: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
J5: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J6: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J7, J9: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical
J8: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical

Connections:
+5V: J1.3 (VCC), J4.2
+12V: J1.9 (+12V), J4.5
-5V: J1.5 (-5V), J4.3
-12V: J1.7 (-12V), J4.4
/AEN: J1.42 (AEN), J9.3
/ALE: J1.28 (ALE), J9.4
/BA00: J1.62 (BA00), J3.20
/BA01: J1.61 (BA01), J3.19
/BA02: J1.60 (BA02), J3.18
/BA03: J1.59 (BA03), J3.17
/BA04: J1.58 (BA04), J3.16
/BA05: J1.57 (BA05), J3.15
/BA06: J1.56 (BA06), J3.14
/BA07: J1.55 (BA07), J3.13
/BA08: J1.54 (BA08), J3.12
/BA09: J1.53 (BA09), J3.11
/BA10: J1.52 (BA10), J3.10
/BA11: J1.51 (BA11), J3.9
/BA12: J1.50 (BA12), J3.8
/BA13: J1.49 (BA13), J3.7
/BA14: J1.48 (BA14), J3.6
/BA15: J1.47 (BA15), J3.5
/BA16: J1.46 (BA16), J3.4
/BA17: J1.45 (BA17), J3.3
/BA18: J1.44 (BA18), J3.2
/BA19: J1.43 (BA19), J3.1
/CLK: J1.20 (CLK), J8.1
/DB0: J1.40 (DB0), J2.8
/DB1: J1.39 (DB1), J2.7
/DB2: J1.38 (DB2), J2.6
/DB3: J1.37 (DB3), J2.5
/DB4: J1.36 (DB4), J2.4
/DB5: J1.35 (DB5), J2.3
/DB6: J1.34 (DB6), J2.2
/DB7: J1.33 (DB7), J2.1
/DRQ1: J1.18 (DRQ1), J7.2
/DRQ2: J1.6 (DRQ2), J7.4
/DRQ3: J1.16 (DRQ3), J7.6
/IO: J1.32 (IO), J9.1
/IO_READY: J1.41 (IO_READY), J9.2
/IRQ2: J1.4 (IRQ2), J5.6
/IRQ3: J1.25 (IRQ3), J5.5
/IRQ4: J1.24 (IRQ4), J5.4
/IRQ5: J1.23 (IRQ5), J5.3
/IRQ6: J1.22 (IRQ6), J5.2
/IRQ7: J1.21 (IRQ7), J5.1
/OSC: J1.30 (OSC), J8.2
/RESET: J1.2 (RESET), J9.7
/TC: J1.27 (TC), J9.5
/UNUSED: J1.8 (UNUSED), J9.6
/~DACK0: J1.19 (~DACK0), J7.1
/~DACK1: J1.17 (~DACK1), J7.3
/~DACK2: J1.26 (~DACK2), J7.5
/~DACK3: J1.15 (~DACK3), J7.7
/~IOR: J1.14 (~IOR), J6.4
/~IOW: J1.13 (~IOW), J6.3
/~SMEMR: J1.12 (~SMEMR), J6.2
/~SMEMW: J1.11 (~SMEMW), J6.1
GND: J1.1 (GND), J1.10 (GND), J1.31 (GND), J4.1

Board: 2 copper layers, 108.9 x 79.7 mm, 9 parts (0 on the bottom side), 59 nets.

## KiCad design isa_extension/isa_extension.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12: 10UF 16V 20%; CP_Radial_D5.0mm_P2.50mm
H1, H2, H3: MountingHole_Pad; MountingHole_4mm_Pad_Via
J1: Samtec SSQ-115-02-T-D-RA; PinHeader_2x31_P2.54mm_Horizontal
J2, J3, J4: Bus_ISA_8bit; 755308430_ISA

Connections:
+5V: C1.1, C2.1, C3.1, C10.1, C11.1, C12.1, J1.5, J1.57, J2.3 (VCC), J2.29 (VCC), J3.3 (VCC), J3.29 (VCC), J4.3 (VCC), J4.29 (VCC)
+12V: C7.1, C8.1, C9.1, J1.17, J2.9 (+12V), J3.9 (+12V), J4.9 (+12V)
-12V: C4.2, C5.2, C6.2, J1.13, J2.7 (-12V), J3.7 (-12V), J4.7 (-12V)
/A0: J1.62, J2.62 (BA00), J3.62 (BA00), J4.62 (BA00)
/A1: J1.60, J2.61 (BA01), J3.61 (BA01), J4.61 (BA01)
/A2: J1.58, J2.60 (BA02), J3.60 (BA02), J4.60 (BA02)
/A3: J1.56, J2.59 (BA03), J3.59 (BA03), J4.59 (BA03)
/A4: J1.54, J2.58 (BA04), J3.58 (BA04), J4.58 (BA04)
/A5: J1.52, J2.57 (BA05), J3.57 (BA05), J4.57 (BA05)
/A6: J1.50, J2.56 (BA06), J3.56 (BA06), J4.56 (BA06)
/A7: J1.48, J2.55 (BA07), J3.55 (BA07), J4.55 (BA07)
/A8: J1.46, J2.54 (BA08), J3.54 (BA08), J4.54 (BA08)
/A9: J1.44, J2.53 (BA09), J3.53 (BA09), J4.53 (BA09)
/A10: J1.42, J2.52 (BA10), J3.52 (BA10), J4.52 (BA10)
/A11: J1.40, J2.51 (BA11), J3.51 (BA11), J4.51 (BA11)
/A12: J1.38, J2.50 (BA12), J3.50 (BA12), J4.50 (BA12)
/A13: J1.36, J2.49 (BA13), J3.49 (BA13), J4.49 (BA13)
/A14: J1.34, J2.48 (BA14), J3.48 (BA14), J4.48 (BA14)
/A15: J1.32, J2.47 (BA15), J3.47 (BA15), J4.47 (BA15)
/A16: J1.30, J2.46 (BA16), J3.46 (BA16), J4.46 (BA16)
/A17: J1.28, J2.45 (BA17), J3.45 (BA17), J4.45 (BA17)
/A18: J1.26, J2.44 (BA18), J3.44 (BA18), J4.44 (BA18)
/A19: J1.24, J2.43 (BA19), J3.43 (BA19), J4.43 (BA19)
/AEN: J1.22, J2.42 (AEN), J3.42 (AEN), J4.42 (AEN)
/ALE: J1.55, J2.28 (ALE), J3.28 (ALE), J4.28 (ALE)
/CLK: J1.39, J2.20 (CLK), J3.20 (CLK), J4.20 (CLK)
/D0: J1.18, J2.40 (DB0), J3.40 (DB0), J4.40 (DB0)
/D1: J1.16, J2.39 (DB1), J3.39 (DB1), J4.39 (DB1)
/D2: J1.14, J2.38 (DB2), J3.38 (DB2), J4.38 (DB2)
/D3: J1.12, J2.37 (DB3), J3.37 (DB3), J4.37 (DB3)
/D4: J1.10, J2.36 (DB4), J3.36 (DB4), J4.36 (DB4)
/D5: J1.8, J2.35 (DB5), J3.35 (DB5), J4.35 (DB5)
/D6: J1.6, J2.34 (DB6), J3.34 (DB6), J4.34 (DB6)
/D7: J1.4, J2.33 (DB7), J3.33 (DB7), J4.33 (DB7)
/DRQ1: J1.35, J2.18 (DRQ1), J3.18 (DRQ1), J4.18 (DRQ1)
/DRQ2: J1.11, J2.6 (DRQ2), J3.6 (DRQ2), J4.6 (DRQ2)
/DRQ3: J1.31, J2.16 (DRQ3), J3.16 (DRQ3), J4.16 (DRQ3)
/IO_CH_CHK: J1.2, J2.32 (IO_CH_CHK), J3.32 (IO_CH_CHK), J4.32 (IO_CH_CHK)
/IO_READY: J1.20, J2.41 (IO_CH_READY), J3.41 (IO_CH_READY), J4.41 (IO_CH_READY)
/IRQ3: J1.49, J2.25 (IRQ3), J3.25 (IRQ3), J4.25 (IRQ3)
/IRQ4: J1.47, J2.24 (IRQ4), J3.24 (IRQ4), J4.24 (IRQ4)
/IRQ5: J1.45, J2.23 (IRQ5), J3.23 (IRQ5), J4.23 (IRQ5)
/IRQ6: J1.43, J2.22 (IRQ6), J3.22 (IRQ6), J4.22 (IRQ6)
/IRQ7: J1.41, J2.21 (IRQ7), J3.21 (IRQ7), J4.21 (IRQ7)
/OSC: J1.59, J2.30 (OSC), J3.30 (OSC), J4.30 (OSC)
/RESET: J1.3, J2.2 (RESET), J3.2 (RESET), J4.2 (RESET)
/TC: J1.53, J2.27 (TC), J3.27 (TC), J4.27 (TC)
/~DACK0: J1.37, J2.19 (~DACK0), J3.19 (~DACK0), J4.19 (~DACK0)
/~DACK1: J1.33, J2.17 (~DACK1), J3.17 (~DACK1), J4.17 (~DACK1)
/~DACK2: J1.51, J2.26 (~DACK2), J3.26 (~DACK2), J4.26 (~DACK2)
/~DACK3: J1.29, J2.15 (~DACK3), J3.15 (~DACK3), J4.15 (~DACK3)
/~IOR: J1.27, J2.14 (~IOR), J3.14 (~IOR), J4.14 (~IOR)
/~IOW: J1.25, J2.13 (~IOW), J3.13 (~IOW), J4.13 (~IOW)
/~MEMR: J1.23, J2.12 (~SMEMR), J3.12 (~SMEMR), J4.12 (~SMEMR)
/~MEMW: J1.21, J2.11 (~SMEMW), J3.11 (~SMEMW), J4.11 (~SMEMW)
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, H1.1, H2.1, H3.1, J1.1, J1.19, J1.61, J2.1 (GND), J2.10 (GND), J2.31 (GND), J3.1 (GND), J3.10 (GND), J3.31 (GND), J4.1 (GND), J4.10 (GND), J4.31 (GND)

Board: 2 copper layers, 73.0 x 123.6 mm, 19 parts (0 on the bottom side), 56 nets.

## Commit log (part)

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2024-04-16 first revision
2024-04-16 add notes file
2024-04-16 kicad gitignore
2024-04-17 bringing over learnings/improvements from prototype board
2024-04-19 more pcb routing, implementing learnings from the prototype board
2024-04-20 more pcb routing
2024-04-23 pcb is fully routed, working on power capacitor tweaks, some ROM testing
2024-04-24 added ATtiny for SMC, added PC speaker
2024-04-24 remove placeholder text on pcb
2024-04-27 more work on test BIOS, porting stuff to C
2024-04-27 emit a.out from linker to get labels in disassembly
2024-05-02 fix a few schematic bugs, missing pull-ups and pull-downs in particular
2024-05-05 tweaks and fixes from real hardware testing
2024-05-06 schematic fixes for DMA HRQ, DMA active cycle
2024-05-08 fix linker issues, more BIOS stuff from ms-dos encyclopedia
2024-05-10 stop writing C, BIOS is very close to functional
2024-05-11 more work on keyboard, making the thing work with XT-IDE
2024-05-11 add memory count back in, set EBDA segment
2024-05-11 more work towards working with the xt-ide
2024-05-11 reintroduce kbc init
2024-05-11 kbc debugging on real hw
2024-05-12 handle keyboard putting a BAT response in the buffer, ask for HDD by default
2024-05-12 kb leds + basic numpad support
2024-05-12 remove build.bat, no longer needed
2024-05-12 recording notes from first 'real use' session
2024-05-13 some kb overrun handling, modifiers much more stable, EDIT.COM works better
2024-05-14 fix accidental DS/ES swap in int16 handler
2024-05-14 detect serial/parallel ports, put in BDA, fix delay_ticks, fix parameter smash in int14,2
2024-05-14 remove spurious POST code
2024-05-14 remove message from int13 handler
2024-05-15 fully revamp build system, add F11/F12/ctrl-alt-del to keyboard handler
2024-05-15 fix KBC/PPI CS# schematic bugs, add ISA expansion header for adding more cards
2024-05-15 add KiCad project for ISA extension board
2024-05-15 add missing ret
2024-05-15 stop dumping kbc status to 7-seg displays
2024-05-16 add a DMA test that doesn't require a device (need to check my schematic fixes)
2024-07-06 add discharge resistors for all power rails
2024-07-06 working on removing DMA for now
2024-08-08 rev A3 pcb, added a fun logo to the BIOS startup
2024-09-04 fixes, prep for final production run
2024-09-04 bump cpu to 8mhz, add second clock gen for ISA bus and PIT
2024-09-04 small routing tweaks for better zone fills
2024-09-05 part tweaks, BOM is pretty much finalized, use 0.5W resistors for bleeders
2024-09-06 minor BOM tweaks due part availability. make some pcb routing a little nicer.
2024-09-19 routing tweaks, use identity comparator instead of OR gates for IO decode
2024-09-19 gitignore tweak
2024-09-19 add additional schematics
2024-09-19 update readmes, licenses
2024-09-19 fix readme license references
2024-09-19 beginnings of a manual
2024-09-21 more work on the manual
2024-09-21 fix part selection for i2c card
2024-09-22 more manual stuff
2024-09-28 add initial i2c bridge code, it works
2024-09-28 add exception handlers, I2C fixes from real testing
2024-09-28 fix manual gitignore
2024-10-05 no more SMT for isa_i2c, tweak motherboard multiplex logic, handful of other tweaks
2024-10-06 i2c card tweaks, manual tweaks
2024-10-06 small tidyups
2024-10-06 add the m88.computer website to the repo
2024-10-09 simplify m88 logic further, reduce ICs, reorient the POST display, use an oscillator for 14.31818 MHz, update isa-i2c bridge BOM
2024-10-09 add the attiny13a source code
2024-10-09 manual tweaks based on schematic updates
2024-10-11 isa_i2c: current-limit the reset line inverter
2024-10-11 m88: use a dip-8 style oscillator footprint, not fully routed yet
2024-10-11 m88: use round-hole socket for BIOS ROM by default
2024-10-14 Bump astro from 4.15.11 to 4.16.1 in /website
    Bumps [astro](https://github.com/withastro/astro/tree/HEAD/packages/astro) from 4.15.11 to 4.16.1.
    - [Release notes](https://github.com/withastro/astro/releases)
    - [Changelog](https://github.com/withastro/astro/blob/main/packages/astro/CHANGELOG.md)
    - [Commits](https://github.com/withastro/astro/commits/astro@4.16.1/packages/astro)
    ---
    updated-dependencies:
2024-10-22 motherboard tweaks for manufacturing run, i2c card tweaks for manufacturing run, de9 -> stemma adapter idea for the i2c card
2024-10-31 add PCB errata to manual
2024-12-16 Bump nanoid from 3.3.7 to 3.3.8 in /website
    Bumps [nanoid](https://github.com/ai/nanoid) from 3.3.7 to 3.3.8.
    - [Release notes](https://github.com/ai/nanoid/releases)
    - [Changelog](https://github.com/ai/nanoid/blob/main/CHANGELOG.md)
    - [Commits](https://github.com/ai/nanoid/compare/3.3.7...3.3.8)
    ---
    updated-dependencies:
2024-12-18 Bump astro from 4.15.11 to 4.16.17 in /website
    Bumps [astro](https://github.com/withastro/astro/tree/HEAD/packages/astro) from 4.15.11 to 4.16.17.
    - [Release notes](https://github.com/withastro/astro/releases)
    - [Changelog](https://github.com/withastro/astro/blob/astro@4.16.17/packages/astro/CHANGELOG.md)
    - [Commits](https://github.com/withastro/astro/commits/astro@4.16.17/packages/astro)
    ---
    updated-dependencies:
2024-12-19 Bump astro from 4.15.11 to 4.16.18 in /website
    Bumps [astro](https://github.com/withastro/astro/tree/HEAD/packages/astro) from 4.15.11 to 4.16.18.
    - [Release notes](https://github.com/withastro/astro/releases)
    - [Changelog](https://github.com/withastro/astro/blob/astro@4.16.18/packages/astro/CHANGELOG.md)
    - [Commits](https://github.com/withastro/astro/commits/astro@4.16.18/packages/astro)
    ---
    updated-dependencies:
2025-02-15 add starter code for i2c.exe
2025-02-15 add more functionality to i2c tool
2025-02-15 Fix i2c.exe logic after real hardware testing
2025-02-16 Improvements to the I2C program
2025-02-16 Don't fprintf in i2c.lib
2025-02-17 initial draft of i2c quickstart guide
2025-03-24 Bump prismjs from 1.29.0 to 1.30.0 in /website
    Bumps [prismjs](https://github.com/PrismJS/prism) from 1.29.0 to 1.30.0.
    - [Release notes](https://github.com/PrismJS/prism/releases)
    - [Changelog](https://github.com/PrismJS/prism/blob/master/CHANGELOG.md)
    - [Commits](https://github.com/PrismJS/prism/compare/v1.29.0...v1.30.0)
    ---
    updated-dependencies:
2025-03-24 Bump undici from 5.28.4 to 5.29.0 in /website
    Bumps [undici](https://github.com/nodejs/undici) from 5.28.4 to 5.29.0.
    - [Release notes](https://github.com/nodejs/undici/releases)
    - [Commits](https://github.com/nodejs/undici/compare/v5.28.4...v5.29.0)
    ---
    updated-dependencies:
    - dependency-name: undici
2025-03-24 Bump vite from 5.4.11 to 5.4.14 in /website
    Bumps [vite](https://github.com/vitejs/vite/tree/HEAD/packages/vite) from 5.4.11 to 5.4.14.
    - [Release notes](https://github.com/vitejs/vite/releases)
    - [Changelog](https://github.com/vitejs/vite/blob/v5.4.14/packages/vite/CHANGELOG.md)
    - [Commits](https://github.com/vitejs/vite/commits/v5.4.14/packages/vite)
    ---
    updated-dependencies:
2025-08-10 update i2c quickstart document
2025-08-10 website updates
2025-08-11 i2c Makefile, option ROM improvements
2025-08-11 add i2c zip release make rule
2025-08-20 Bump astro from 5.12.9 to 5.13.1 in /website
    Bumps [astro](https://github.com/withastro/astro/tree/HEAD/packages/astro) from 5.12.9 to 5.13.1.
    - [Release notes](https://github.com/withastro/astro/releases)
    - [Changelog](https://github.com/withastro/astro/blob/main/packages/astro/CHANGELOG.md)
    - [Commits](https://github.com/withastro/astro/commits/astro@5.13.1/packages/astro)
    ---
    updated-dependencies:
2025-09-10 Bump vite from 6.3.5 to 6.3.6 in /website
    Bumps [vite](https://github.com/vitejs/vite/tree/HEAD/packages/vite) from 6.3.5 to 6.3.6.
    - [Release notes](https://github.com/vitejs/vite/releases)
    - [Changelog](https://github.com/vitejs/vite/blob/v6.3.6/packages/vite/CHANGELOG.md)
    - [Commits](https://github.com/vitejs/vite/commits/v6.3.6/packages/vite)
    ---
    updated-dependencies:
2025-10-11 Bump astro from 5.12.9 to 5.14.3 in /website
    Bumps [astro](https://github.com/withastro/astro/tree/HEAD/packages/astro) from 5.12.9 to 5.14.3.
    - [Release notes](https://github.com/withastro/astro/releases)
    - [Changelog](https://github.com/withastro/astro/blob/main/packages/astro/CHANGELOG.md)
    - [Commits](https://github.com/withastro/astro/commits/astro@5.14.3/packages/astro)
    ---
    updated-dependencies:
2025-10-21 Bump vite from 6.3.5 to 6.4.1 in /website
    Bumps [vite](https://github.com/vitejs/vite/tree/HEAD/packages/vite) from 6.3.5 to 6.4.1.
    - [Release notes](https://github.com/vitejs/vite/releases)
    - [Changelog](https://github.com/vitejs/vite/blob/main/packages/vite/CHANGELOG.md)
    - [Commits](https://github.com/vitejs/vite/commits/create-vite@6.4.1/packages/vite)
    ---
    updated-dependencies:
2025-11-13 Bump astro from 5.12.9 to 5.15.6 in /website
    Bumps [astro](https://github.com/withastro/astro/tree/HEAD/packages/astro) from 5.12.9 to 5.15.6.
    - [Release notes](https://github.com/withastro/astro/releases)
    - [Changelog](https://github.com/withastro/astro/blob/main/packages/astro/CHANGELOG.md)
    - [Commits](https://github.com/withastro/astro/commits/astro@5.15.6/packages/astro)
    ---
    updated-dependencies:
2025-11-16 Bump js-yaml from 4.1.0 to 4.1.1 in /website
    Bumps [js-yaml](https://github.com/nodeca/js-yaml) from 4.1.0 to 4.1.1.
    - [Changelog](https://github.com/nodeca/js-yaml/blob/master/CHANGELOG.md)
    - [Commits](https://github.com/nodeca/js-yaml/compare/4.1.0...4.1.1)
    ---
    updated-dependencies:
    - dependency-name: js-yaml
2025-11-19 Bump astro from 5.12.9 to 5.15.9 in /website
    Bumps [astro](https://github.com/withastro/astro/tree/HEAD/packages/astro) from 5.12.9 to 5.15.9.
    - [Release notes](https://github.com/withastro/astro/releases)
    - [Changelog](https://github.com/withastro/astro/blob/main/packages/astro/CHANGELOG.md)
    - [Commits](https://github.com/withastro/astro/commits/astro@5.15.9/packages/astro)
    ---
    updated-dependencies:
2025-12-02 Bump mdast-util-to-hast from 13.2.0 to 13.2.1 in /website
    Bumps [mdast-util-to-hast](https://github.com/syntax-tree/mdast-util-to-hast) from 13.2.0 to 13.2.1.
    - [Release notes](https://github.com/syntax-tree/mdast-util-to-hast/releases)
    - [Commits](https://github.com/syntax-tree/mdast-util-to-hast/compare/13.2.0...13.2.1)
    ---
    updated-dependencies:
    - dependency-name: mdast-util-to-hast
2026-01-15 Bump h3 from 1.15.4 to 1.15.5 in /website
    Bumps [h3](https://github.com/h3js/h3) from 1.15.4 to 1.15.5.
    - [Release notes](https://github.com/h3js/h3/releases)
    - [Changelog](https://github.com/h3js/h3/blob/v1.15.5/CHANGELOG.md)
    - [Commits](https://github.com/h3js/h3/compare/v1.15.4...v1.15.5)
    ---
    updated-dependencies:
2026-01-15 Bump devalue from 5.1.1 to 5.6.2 in /website
    Bumps [devalue](https://github.com/sveltejs/devalue) from 5.1.1 to 5.6.2.
    - [Release notes](https://github.com/sveltejs/devalue/releases)
    - [Changelog](https://github.com/sveltejs/devalue/blob/main/CHANGELOG.md)
    - [Commits](https://github.com/sveltejs/devalue/compare/v5.1.1...v5.6.2)
    ---
    updated-dependencies:
2026-01-20 Bump diff from 5.2.0 to 5.2.2 in /website
    Bumps [diff](https://github.com/kpdecker/jsdiff) from 5.2.0 to 5.2.2.
    - [Changelog](https://github.com/kpdecker/jsdiff/blob/master/release-notes.md)
    - [Commits](https://github.com/kpdecker/jsdiff/compare/v5.2.0...v5.2.2)
    ---
    updated-dependencies:
    - dependency-name: diff
